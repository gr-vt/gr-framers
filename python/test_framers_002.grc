<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>framers_gr_hdlc_framer_b</key>
<param><key>id</key><value>framers_gr_hdlc_framer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vector</value></param>
<param><key>value</key><value>(1,2,3,4,5,4,3,2,1)</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>test_framers_002</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>message_file_msg_vector_strobe</key>
<param><key>id</key><value>message_file_msg_vector_strobe_0</value></param>
<param><key>high</key><value>10</value></param>
<param><key>low</key><value>10</value></param>
<param><key>msg_vector</key><value>vector</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>framers_gr_hdlc_framer_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>message_file_msg_vector_strobe_0</source_block_id><sink_block_id>framers_gr_hdlc_framer_b_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>0</sink_key></connection>
</flow_graph>
