<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_name</value></param>
<param><key>value</key><value>"infile.dat"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate*8</value></param>
</block>
<block>
<key>framers_gr_hdlc_framer_b</key>
<param><key>id</key><value>framers_gr_hdlc_framer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>message_file_message_file_sink</key>
<param><key>id</key><value>message_file_message_file_sink_0</value></param>
<param><key>filename</key><value>/home/tacew/projects/tacew/pybombs/src/gr-framers/python/outfile.dat</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>append</key><value>False</value></param>
</block>
<block>
<key>message_file_message_strobe_source</key>
<param><key>id</key><value>message_file_message_strobe_source_0</value></param>
<param><key>file</key><value>/home/tacew/projects/tacew/pybombs/src/gr-framers/python/infile.dat</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>high</key><value>1000</value></param>
<param><key>low</key><value>1000</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>test_framers_001</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>max_nouts</key><value>1</value></param>
</block>
<connection><source_block_id>framers_gr_hdlc_framer_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>message_file_message_strobe_source_0</source_block_id><sink_block_id>framers_gr_hdlc_framer_b_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>message_file_message_file_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
