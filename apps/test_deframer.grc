<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
</block>
<block>
<key>blocks_short_to_char</key>
<param><key>id</key><value>blocks_short_to_char_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>const</key><value>0</value></param>
</block>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_short_to_char_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_short_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
